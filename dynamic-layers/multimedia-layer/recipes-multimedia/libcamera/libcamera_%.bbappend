EXTRA_OEMESON:raspberrypi4-64 = " \
    -Dpipelines=raspberrypi,uvcvideo \
    -Dipas=raspberrypi,vimc \
    -Dv4l2=true \
    -Dcam=enabled \
    -Dlc-compliance=disabled \
    -Dtest=false \
    -Ddocumentation=disabled \
"
